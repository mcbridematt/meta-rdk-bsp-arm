SYSTEMD_SERVICE_${PN}:remove = "RdkInterDeviceManager.service"
